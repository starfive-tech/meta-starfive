ALTERNATIVE:${PN}-ubifs = "ubiformat ubiattach ubidetach ubimkvol ubirename ubirmvol ubirsvol ubiupdatevol"
ALTERNATIVE_LINK_NAME[ubiformat] = "${sbindir}/ubiformat"

EXTRA_OECONF_append_riscv64 = " --with-arch=rv64gcv_zba_zbb --with-cmodel=medany"

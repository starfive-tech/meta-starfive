EXTRA_OECONF_append_riscv64 = " --with-arch=rv64gcb CFLAGS_FOR_TARGET="-O2 -mcmodel=medany"  CXXFLAGS_FOR_TARGET="-O2 -mcmodel=medany""

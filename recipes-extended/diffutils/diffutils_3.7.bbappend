FILESEXTRAPATHS_prepend := "${THISDIR}/diffutils:"

SRC_URI += "file://0001-c-stack-stop-using-SIGSTKSZ.patch \
           "

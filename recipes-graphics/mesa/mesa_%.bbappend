FILESEXTRAPATHS:prepend := "${THISDIR}/mesa:"

SRC_URI += "file://0001-fix-LLVMOpaqueModule.patch"

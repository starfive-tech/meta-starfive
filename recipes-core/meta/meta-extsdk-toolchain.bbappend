DEPENDS:append = " clang-cross-${TARGET_ARCH}"

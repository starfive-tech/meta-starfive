EXTRA_OEMESON:append:starfive-dubhe = " -Ddefault-timeout-sec=600"

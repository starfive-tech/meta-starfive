FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI = "file://init-boot.sh"


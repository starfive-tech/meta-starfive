EXTRA_OEMAKE += "NO_LIBTRACEEVENT=1"

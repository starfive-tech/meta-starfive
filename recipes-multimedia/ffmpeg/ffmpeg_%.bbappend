PACKAGECONFIG:append = " gpl mp3lame libopus speex srt theora libvorbis vpx sdl2 "

